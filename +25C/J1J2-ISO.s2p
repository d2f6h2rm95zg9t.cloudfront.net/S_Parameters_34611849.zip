!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 21:02:59
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -69.55 dB at 35.83 GHz (marker M1); lowest = -123.3 dB at 2.635 GHz (marker M2)
!   lowest |S11| = -36.0 dB at 20.12 GHz (marker M3), VSWR 1.03, Z = 50.9 + j1.29 ohm
!   |S11| at or under -10 dB: start of sweep to 28.26 GHz; 29.51 GHz to end of sweep
!   |S22| runs from -44.5 to -10.2 dB; largest |S21 - S12| = 5.4e-05
!   the Smith chart shows 8.995 GHz to 32.25 GHz only
!   S11 on the Smith chart (normalised r, x): 8.995 GHz: 0.98, +0.16; 14.76 GHz: 1.47, -0.11; 24.5 GHz: 0.76, +0.19; 28.67 GHz: 1.00, +0.72; 32.25 GHz: 0.97, -0.03
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -19.3  -93.5  -93.3  -10.2
! 2.635 GHz  -26.7  -123.3  -112.4  -14.0
! 7.008 GHz  -17.5  -104.6  -103.3  -15.7
! 8.995 GHz  -22.1  -104.0  -102.7  -14.6
! 9.989 GHz  -30.0  -104.2  -108.6  -15.9
! 13.57 GHz  -11.6  -107.4  -110.9  -18.2
! 14.76 GHz  -14.1  -103.3  -101.9  -19.4
! 18.54 GHz  -13.8  -95.5  -97.9  -32.8
! 19.53 GHz  -21.6  -97.8  -99.6  -27.8
! 20.12 GHz  -36.0  -87.9  -94.7  -24.9
! 20.92 GHz  -20.4  -103.0  -106.7  -22.5
! 24.5 GHz  -15.1  -92.4  -93.7  -16.8
! 26.88 GHz  -19.0  -85.2  -85.3  -14.4
! 28.67 GHz  -9.4  -90.3  -96.3  -14.1
! 31.25 GHz  -17.0  -94.5  -85.4  -17.0
! 32.25 GHz  -33.1  -85.1  -82.4  -20.7
! 33.44 GHz  -13.3  -81.8  -84.8  -27.5
! 34.44 GHz  -10.9  -73.2  -73.4  -44.5
! 35.83 GHz  -14.5  -69.5  -69.9  -27.3
! 38.01 GHz  -10.6  -84.6  -86.0  -19.7
! 39.2 GHz  -19.2  -81.3  -86.7  -20.2
! 40 GHz  -11.0  -93.7  -88.8  -19.3
