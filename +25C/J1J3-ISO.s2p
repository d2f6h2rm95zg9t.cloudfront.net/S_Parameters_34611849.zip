!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 21:06:01
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -71.14 dB at 36.22 GHz (marker M1); lowest = -117.5 dB at 13.17 GHz (marker M2)
!   lowest |S11| = -29.6 dB at 26.48 GHz (marker M3), VSWR 1.07, Z = 52.5 - j2.26 ohm
!   |S11| at or under -10 dB: start of sweep to 28.42 GHz; 29.98 GHz to 37.41 GHz (7.43 GHz wide, 22 % of centre); 38.96 GHz to 39.94 GHz (982.1 MHz wide, 2.49 % of centre)
!   |S22| runs from -25.9 to -9.9 dB; largest |S21 - S12| = 5.1e-05
!   the Smith chart shows 12.77 GHz to 35.63 GHz only
!   S11 on the Smith chart (normalised r, x): 12.77 GHz: 0.64, +0.28; 16.15 GHz: 0.69, +0.06; 21.52 GHz: 0.92, -0.23; 28.67 GHz: 0.89, +0.66; 35.63 GHz: 1.60, +0.38
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -19.3  -81.5  -81.1  -9.9
! 3.033 GHz  -26.3  -105.7  -114.6  -12.3
! 7.008 GHz  -17.2  -115.0  -102.4  -15.9
! 9.989 GHz  -24.4  -100.7  -104.5  -15.0
! 12.77 GHz  -11.3  -106.9  -109.2  -15.3
! 13.17 GHz  -10.8  -117.5  -115.1  -15.4
! 13.57 GHz  -10.8  -103.3  -108.7  -15.6
! 16.15 GHz  -14.6  -93.9  -97.2  -18.0
! 18.34 GHz  -13.4  -96.8  -94.1  -21.8
! 20.12 GHz  -24.5  -95.0  -89.4  -25.1
! 21.52 GHz  -18.0  -90.1  -94.3  -25.2
! 24.89 GHz  -18.3  -89.7  -90.1  -19.0
! 26.48 GHz  -29.6  -91.1  -93.2  -16.6
! 26.88 GHz  -23.6  -88.6  -101.8  -16.4
! 28.67 GHz  -9.5  -100.2  -102.2  -16.6
! 31.25 GHz  -13.3  -82.1  -82.7  -16.4
! 31.85 GHz  -16.9  -73.3  -73.0  -15.6
! 32.65 GHz  -25.7  -77.8  -79.5  -14.3
! 33.44 GHz  -15.1  -77.6  -76.8  -13.4
! 35.63 GHz  -11.3  -71.7  -72.2  -11.6
! 36.22 GHz  -12.7  -71.1  -71.5  -11.3
! 40 GHz  -9.9  -90.6  -95.5  -14.2
