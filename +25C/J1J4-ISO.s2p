!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 21:08:04
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -68.85 dB at 35.63 GHz (marker M1); lowest = -123.1 dB at 2.635 GHz (marker M2)
!   lowest |S11| = -39.0 dB at 20.12 GHz (marker M3), VSWR 1.02, Z = 49.5 + j0.988 ohm
!   |S11| at or under -10 dB: start of sweep to 28.23 GHz; 29.48 GHz to end of sweep
!   |S22| runs from -58.6 to -9.9 dB; largest |S21 - S12| = 5.6e-05
!   the Smith chart shows 8.995 GHz to 32.45 GHz only
!   S11 on the Smith chart (normalised r, x): 8.995 GHz: 0.97, +0.16; 14.76 GHz: 1.46, -0.12; 28.67 GHz: 1.00, +0.73; 32.45 GHz: 0.98, -0.09
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -19.3  -79.6  -79.7  -9.9
! 2.635 GHz  -26.6  -123.1  -102.9  -14.1
! 7.008 GHz  -17.4  -115.5  -104.3  -15.8
! 8.995 GHz  -21.9  -99.9  -102.8  -13.7
! 9.989 GHz  -28.9  -101.0  -98.1  -14.8
! 13.57 GHz  -11.5  -103.2  -107.9  -16.4
! 14.76 GHz  -14.3  -106.8  -105.1  -17.4
! 18.54 GHz  -13.9  -97.4  -92.9  -28.0
! 19.53 GHz  -21.3  -98.9  -95.2  -34.9
! 20.12 GHz  -39.0  -90.4  -93.8  -42.8
! 20.52 GHz  -25.2  -88.7  -93.5  -58.6
! 21.32 GHz  -17.4  -91.4  -97.7  -41.7
! 26.88 GHz  -19.3  -83.8  -82.4  -19.6
! 28.67 GHz  -9.3  -97.3  -89.3  -19.0
! 31.25 GHz  -16.9  -87.4  -84.4  -17.5
! 32.25 GHz  -33.2  -77.0  -77.7  -16.1
! 32.45 GHz  -26.9  -80.0  -81.2  -15.9
! 33.44 GHz  -13.2  -78.4  -78.8  -14.8
! 35.63 GHz  -13.5  -68.9  -68.8  -12.5
! 38.01 GHz  -10.6  -98.0  -94.4  -12.4
! 39.2 GHz  -18.9  -81.6  -79.9  -13.0
! 40 GHz  -11.2  -85.0  -83.9  -13.5
