!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 23:26:14
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -75.25 dB at 34.83 GHz (marker M1); lowest = -122.8 dB at 2.834 GHz (marker M2)
!   lowest |S11| = -30.7 dB at 8.2 GHz (marker M3), VSWR 1.06, Z = 47.9 + j1.94 ohm
!   |S11| at or under -10 dB: start of sweep to 13.87 GHz; 14.85 GHz to end of sweep
!   |S22| runs from -25.5 to -9.9 dB; largest |S21 - S12| = 4.7e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.20, -0.11; 17.54 GHz: 1.71, -0.22; 23.7 GHz: 1.06, -0.49; 33.84 GHz: 0.94, -0.11; 40 GHz: 0.94, +0.18
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -19.5  -89.8  -91.6  -9.9
! 1.84 GHz  -28.1  -110.8  -104.1  -14.9
! 2.834 GHz  -26.8  -122.8  -104.8  -13.3
! 5.02 GHz  -19.1  -109.2  -118.5  -15.5
! 7.008 GHz  -23.6  -122.4  -126.4  -15.9
! 8.2 GHz  -30.7  -101.0  -118.4  -10.9
! 9.591 GHz  -24.2  -105.9  -99.3  -14.9
! 10.78 GHz  -27.1  -98.3  -104.6  -15.0
! 13.57 GHz  -10.5  -100.2  -118.5  -15.6
! 17.54 GHz  -11.2  -95.1  -91.0  -20.3
! 20.12 GHz  -15.0  -100.9  -91.7  -24.9
! 23.7 GHz  -12.7  -91.6  -94.1  -20.7
! 26.88 GHz  -12.7  -92.9  -91.1  -16.4
! 28.47 GHz  -12.8  -93.6  -93.3  -16.5
! 29.86 GHz  -23.0  -102.8  -99.8  -17.3
! 32.25 GHz  -17.3  -78.9  -80.9  -15.0
! 33.44 GHz  -21.1  -83.1  -80.6  -13.3
! 33.84 GHz  -23.9  -79.7  -81.2  -12.7
! 34.83 GHz  -23.7  -75.3  -75.9  -12.0
! 36.02 GHz  -15.5  -85.0  -83.9  -11.4
! 38.41 GHz  -11.5  -92.0  -90.8  -12.8
! 40 GHz  -20.5  -89.8  -87.1  -14.1
