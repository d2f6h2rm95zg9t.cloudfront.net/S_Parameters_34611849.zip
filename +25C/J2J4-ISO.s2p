!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 23:27:37
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -75.85 dB at 40 GHz (marker M1); lowest = -127.7 dB at 16.35 GHz (marker M2)
!   lowest |S11| = -30.7 dB at 8.2 GHz (marker M3), VSWR 1.06, Z = 47.9 + j1.94 ohm
!   |S11| at or under -10 dB: start of sweep to 13.87 GHz; 14.85 GHz to end of sweep
!   |S22| runs from -63.1 to -9.9 dB; largest |S21 - S12| = 5.4e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.20, -0.11; 17.54 GHz: 1.71, -0.22; 23.7 GHz: 1.06, -0.49; 33.84 GHz: 0.93, -0.11; 40 GHz: 0.94, +0.18
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -19.5  -82.8  -84.1  -9.9
! 2.039 GHz  -28.5  -98.4  -103.9  -15.2
! 5.02 GHz  -19.1  -118.9  -106.6  -15.5
! 7.008 GHz  -23.6  -111.2  -127.6  -15.8
! 8.2 GHz  -30.7  -111.4  -105.9  -10.5
! 9.591 GHz  -24.2  -102.9  -98.7  -14.6
! 10.78 GHz  -27.1  -102.0  -97.7  -15.0
! 13.57 GHz  -10.5  -103.5  -111.6  -16.4
! 16.35 GHz  -11.7  -127.7  -101.0  -20.7
! 17.54 GHz  -11.2  -96.2  -94.7  -24.4
! 20.12 GHz  -15.0  -111.5  -95.3  -42.1
! 20.32 GHz  -14.7  -104.2  -96.5  -47.4
! 20.52 GHz  -14.6  -107.0  -90.6  -63.1
! 21.12 GHz  -14.6  -102.4  -92.9  -41.9
! 23.7 GHz  -12.7  -103.4  -87.3  -27.9
! 26.88 GHz  -12.7  -88.8  -85.4  -19.8
! 28.47 GHz  -12.8  -92.1  -90.2  -18.9
! 29.86 GHz  -23.0  -94.8  -95.3  -19.0
! 33.44 GHz  -21.1  -78.6  -80.7  -14.7
! 33.84 GHz  -23.9  -85.5  -86.2  -14.0
! 38.41 GHz  -11.5  -87.2  -92.1  -12.8
! 40 GHz  -20.5  -75.9  -75.5  -13.3
