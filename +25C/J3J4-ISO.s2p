!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 23:29:32
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -72.57 dB at 36.22 GHz (marker M1); lowest = -125.8 dB at 7.008 GHz (marker M2)
!   lowest |S11| = -41.1 dB at 22.71 GHz (marker M3), VSWR 1.02, Z = 49.1 + j0.0621 ohm
!   |S11| at or under -10 dB: start of sweep to 34.01 GHz; 34.06 GHz to end of sweep
!   |S22| runs from -60.1 to -9.9 dB; largest |S21 - S12| = 4.2e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.20, -0.11; 17.74 GHz: 1.63, -0.43; 27.68 GHz: 0.94, +0.53; 34.24 GHz: 0.64, +0.37; 40 GHz: 1.16, -0.19
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -19.5  -80.9  -79.4  -9.9
! 1.84 GHz  -29.9  -94.5  -102.3  -15.2
! 7.008 GHz  -21.5  -125.8  -109.8  -15.8
! 8.598 GHz  -40.4  -117.2  -100.7  -12.4
! 9.591 GHz  -23.0  -99.6  -103.0  -14.6
! 11.38 GHz  -26.8  -101.7  -104.2  -15.1
! 13.57 GHz  -11.9  -110.0  -104.1  -16.4
! 17.74 GHz  -10.9  -94.6  -93.4  -24.7
! 20.12 GHz  -19.8  -96.1  -92.5  -41.8
! 20.52 GHz  -24.9  -115.6  -90.2  -60.1
! 21.12 GHz  -35.6  -92.2  -96.1  -41.8
! 21.91 GHz  -27.0  -88.7  -90.9  -34.6
! 22.71 GHz  -41.1  -93.3  -88.4  -29.9
! 23.7 GHz  -21.0  -95.1  -90.9  -27.9
! 26.88 GHz  -12.6  -86.2  -88.6  -19.7
! 27.68 GHz  -11.5  -88.1  -92.1  -19.1
! 33.44 GHz  -10.9  -84.1  -86.5  -14.7
! 34.24 GHz  -10.2  -89.6  -87.4  -13.5
! 36.22 GHz  -10.7  -72.6  -72.7  -12.0
! 38.61 GHz  -12.2  -86.4  -88.5  -12.8
! 39.6 GHz  -28.5  -78.2  -79.4  -13.1
! 40 GHz  -18.9  -77.6  -78.5  -13.3
