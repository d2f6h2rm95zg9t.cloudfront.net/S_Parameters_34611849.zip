!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 22:50:02
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -70.44 dB at 35.23 GHz (marker M1); lowest = -127.5 dB at 14.56 GHz (marker M2)
!   lowest |S11| = -38.9 dB at 20.12 GHz (marker M3), VSWR 1.02, Z = 51.1 + j0.165 ohm
!   |S11| at or under -10 dB: start of sweep to 28.29 GHz; 29.42 GHz to end of sweep
!   |S22| runs from -41.6 to -10.1 dB; largest |S21 - S12| = 6.2e-05
!   the Smith chart shows 8.2 GHz to 32.25 GHz only
!   S11 on the Smith chart (normalised r, x): 8.2 GHz: 0.79, +0.07; 14.36 GHz: 1.47, +0.30; 24.7 GHz: 0.84, +0.27; 28.67 GHz: 1.02, +0.73; 32.25 GHz: 0.98, -0.02
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -18.2  -91.4  -91.8  -10.1
! 1.84 GHz  -26.1  -108.7  -107.0  -15.1
! 7.008 GHz  -17.5  -104.0  -107.2  -15.8
! 8.2 GHz  -18.0  -111.9  -104.8  -11.4
! 10.19 GHz  -28.4  -102.5  -103.3  -16.4
! 13.57 GHz  -11.9  -101.1  -107.9  -18.7
! 14.36 GHz  -12.9  -103.5  -108.1  -19.6
! 14.56 GHz  -13.5  -127.5  -98.5  -19.9
! 18.34 GHz  -14.3  -97.7  -91.7  -32.4
! 19.53 GHz  -23.7  -94.5  -93.2  -25.5
! 20.12 GHz  -38.9  -102.0  -95.0  -23.2
! 21.12 GHz  -18.2  -92.4  -92.4  -20.7
! 24.7 GHz  -15.6  -91.5  -90.4  -16.1
! 26.88 GHz  -18.2  -84.6  -82.1  -14.1
! 28.67 GHz  -9.4  -102.8  -92.6  -14.1
! 31.25 GHz  -16.6  -94.6  -91.5  -17.2
! 32.25 GHz  -36.4  -98.2  -102.0  -20.7
! 33.44 GHz  -13.0  -84.9  -85.0  -27.9
! 34.24 GHz  -10.5  -75.8  -75.1  -41.5
! 35.23 GHz  -12.0  -70.4  -70.2  -30.9
! 39.2 GHz  -19.7  -82.6  -80.9  -20.7
! 40 GHz  -11.2  -91.9  -89.7  -19.4
