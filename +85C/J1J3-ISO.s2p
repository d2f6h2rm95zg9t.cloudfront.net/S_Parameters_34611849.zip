!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 22:52:15
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -75.04 dB at 36.22 GHz (marker M1); lowest = -132.3 dB at 5.219 GHz (marker M2)
!   lowest |S11| = -26.7 dB at 3.033 GHz (marker M3), VSWR 1.10, Z = 45.8 + j1.44 ohm
!   |S11| at or under -10 dB: start of sweep to 28.69 GHz; 29.96 GHz to 37.43 GHz (7.475 GHz wide, 22.2 % of centre); 38.44 GHz to end of sweep
!   |S22| runs from -28.1 to -9.8 dB; largest |S21 - S12| = 4.1e-05
!   the Smith chart shows 250 MHz to 28.67 GHz only
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.22, -0.16; 8.598 GHz: 0.89, +0.19; 28.67 GHz: 0.92, +0.63
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -18.3  -78.9  -79.0  -9.8
! 1.244 GHz  -23.6  -105.8  -104.2  -14.3
! 3.033 GHz  -26.7  -101.5  -108.6  -12.4
! 5.219 GHz  -19.5  -132.3  -108.9  -16.0
! 7.008 GHz  -17.3  -109.0  -104.2  -16.0
! 8.598 GHz  -18.6  -99.1  -104.6  -13.2
! 9.989 GHz  -22.9  -105.4  -102.0  -15.4
! 13.57 GHz  -10.9  -101.0  -107.9  -16.3
! 15.75 GHz  -16.5  -93.3  -97.0  -18.1
! 17.54 GHz  -12.4  -94.5  -89.2  -21.8
! 20.12 GHz  -22.1  -88.5  -91.6  -27.5
! 21.91 GHz  -17.3  -93.8  -93.5  -25.0
! 24.89 GHz  -18.3  -88.9  -106.4  -18.8
! 26.29 GHz  -25.7  -92.1  -93.8  -16.8
! 26.88 GHz  -20.5  -91.0  -89.9  -16.6
! 28.67 GHz  -10.0  -85.3  -84.1  -16.8
! 31.25 GHz  -12.9  -84.2  -82.4  -16.6
! 32.65 GHz  -25.9  -85.5  -84.8  -14.7
! 33.44 GHz  -15.2  -86.4  -88.7  -13.6
! 36.22 GHz  -11.8  -75.0  -75.8  -11.5
! 37.22 GHz  -10.6  -80.5  -81.9  -11.6
! 40 GHz  -10.6  -84.2  -87.7  -13.9
