!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 22:54:12
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -72.49 dB at 36.22 GHz (marker M1); lowest = -124.2 dB at 2.635 GHz (marker M2)
!   lowest |S11| = -36.4 dB at 20.12 GHz (marker M3), VSWR 1.03, Z = 51.4 - j0.696 ohm
!   |S11| at or under -10 dB: start of sweep to 28.43 GHz; 29.38 GHz to end of sweep
!   |S22| runs from -52.7 to -9.8 dB; largest |S21 - S12| = 5.7e-05
!   the Smith chart shows 8.2 GHz to 32.45 GHz only
!   S11 on the Smith chart (normalised r, x): 8.2 GHz: 0.77, +0.06; 14.36 GHz: 1.47, +0.29; 25.09 GHz: 0.97, +0.32; 28.87 GHz: 1.22, +0.73; 32.45 GHz: 1.00, -0.11
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -18.5  -78.7  -78.2  -9.8
! 2.635 GHz  -26.7  -124.2  -99.7  -13.9
! 7.008 GHz  -18.0  -115.1  -108.9  -16.0
! 8.2 GHz  -17.6  -119.5  -109.0  -11.0
! 10.19 GHz  -27.3  -100.7  -103.5  -15.2
! 13.57 GHz  -11.8  -111.0  -122.2  -17.0
! 14.36 GHz  -13.0  -110.3  -106.5  -17.6
! 18.34 GHz  -14.4  -93.3  -96.8  -30.5
! 19.33 GHz  -21.8  -96.7  -99.2  -40.0
! 19.73 GHz  -28.4  -93.2  -93.9  -52.7
! 20.12 GHz  -36.4  -96.3  -91.3  -43.2
! 21.32 GHz  -18.0  -90.3  -87.6  -34.8
! 25.09 GHz  -16.0  -90.9  -85.1  -23.6
! 26.88 GHz  -17.6  -84.4  -82.3  -20.0
! 28.87 GHz  -9.7  -84.4  -84.5  -19.0
! 31.25 GHz  -16.5  -84.6  -83.4  -17.6
! 32.05 GHz  -33.2  -83.1  -81.3  -16.7
! 32.45 GHz  -25.3  -87.7  -88.4  -16.3
! 33.44 GHz  -13.0  -93.6  -87.6  -14.9
! 36.22 GHz  -15.6  -72.5  -73.2  -12.2
! 37.42 GHz  -11.2  -80.5  -81.8  -12.3
! 40 GHz  -11.9  -82.5  -82.1  -13.5
