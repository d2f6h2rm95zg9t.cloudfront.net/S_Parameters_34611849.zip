!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Monday, May 26, 2025 14:09:10
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -79.15 dB at 34.63 GHz (marker M1); lowest = -121.1 dB at 2.834 GHz (marker M2)
!   lowest |S11| = -36.5 dB at 7.604 GHz (marker M3), VSWR 1.03, Z = 49 - j1.11 ohm
!   |S11| at or under -10 dB: start of sweep to 13.64 GHz; 14.78 GHz to 38.48 GHz (23.7 GHz wide, 89 % of centre); 38.67 GHz to end of sweep
!   |S22| runs from -29.8 to -9.8 dB; largest |S21 - S12| = 4e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.23, -0.15; 12.37 GHz: 0.91, -0.39; 40 GHz: 0.81, +0.15
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -18.4  -89.6  -91.4  -9.8
! 1.84 GHz  -26.7  -110.1  -112.7  -14.8
! 2.834 GHz  -24.4  -121.1  -108.8  -13.1
! 5.219 GHz  -18.7  -105.4  -107.5  -15.8
! 7.008 GHz  -27.6  -119.4  -107.6  -15.9
! 7.604 GHz  -36.5  -106.7  -107.8  -13.4
! 9.194 GHz  -22.2  -98.7  -97.9  -14.6
! 10.78 GHz  -32.2  -101.7  -108.7  -15.2
! 11.38 GHz  -21.1  -112.0  -109.6  -15.1
! 12.37 GHz  -13.7  -113.8  -100.2  -15.3
! 13.57 GHz  -10.1  -104.1  -104.1  -15.9
! 18.73 GHz  -18.3  -95.0  -99.2  -24.1
! 20.12 GHz  -13.9  -96.7  -91.4  -27.4
! 26.88 GHz  -10.8  -89.4  -91.0  -16.7
! 29.47 GHz  -17.7  -99.7  -93.4  -18.2
! 32.25 GHz  -14.6  -87.5  -86.7  -15.3
! 33.44 GHz  -22.5  -83.5  -85.3  -13.9
! 34.04 GHz  -35.8  -79.5  -79.9  -13.2
! 34.24 GHz  -26.7  -80.2  -79.3  -12.8
! 34.63 GHz  -21.1  -79.2  -79.6  -12.7
! 38.01 GHz  -10.2  -97.7  -99.5  -12.6
! 40 GHz  -17.6  -89.1  -89.8  -14.8
