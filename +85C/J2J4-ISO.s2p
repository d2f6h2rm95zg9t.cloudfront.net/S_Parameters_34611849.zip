!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Monday, May 26, 2025 14:10:25
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -77.49 dB at 31.25 GHz (marker M1); lowest = -126.0 dB at 9.989 GHz (marker M2)
!   lowest |S11| = -34.1 dB at 34.24 GHz (marker M3), VSWR 1.04, Z = 49.8 + j1.96 ohm
!   |S11| at or under -10 dB: start of sweep to 13.87 GHz; 14.74 GHz to end of sweep
!   |S22| runs from -33.6 to -9.3 dB; largest |S21 - S12| = 3.6e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.23, -0.14; 12.37 GHz: 0.94, -0.37; 40 GHz: 0.88, +0.15
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -18.4  -83.1  -83.0  -9.3
! 1.84 GHz  -27.2  -103.6  -107.9  -15.2
! 5.02 GHz  -19.1  -123.6  -107.3  -16.2
! 7.008 GHz  -26.5  -108.0  -110.7  -14.7
! 8.001 GHz  -32.8  -111.5  -108.1  -10.1
! 8.995 GHz  -24.4  -103.2  -99.4  -13.7
! 9.989 GHz  -24.9  -126.0  -105.8  -15.6
! 10.78 GHz  -28.6  -113.3  -108.6  -16.6
! 12.37 GHz  -14.5  -104.7  -100.7  -17.9
! 13.57 GHz  -10.4  -102.0  -111.2  -18.8
! 20.12 GHz  -14.5  -96.7  -101.0  -32.8
! 22.71 GHz  -13.3  -98.6  -99.4  -24.0
! 26.88 GHz  -11.4  -90.2  -89.5  -22.6
! 28.47 GHz  -12.5  -90.7  -97.4  -22.5
! 29.86 GHz  -20.4  -87.0  -86.0  -20.7
! 31.25 GHz  -16.8  -77.5  -77.3  -18.5
! 33.44 GHz  -23.0  -93.4  -88.0  -15.8
! 34.24 GHz  -34.1  -91.8  -92.5  -14.5
! 34.83 GHz  -20.2  -88.6  -92.5  -14.1
! 35.83 GHz  -15.0  -93.9  -90.8  -13.2
! 38.61 GHz  -10.8  -93.9  -88.6  -14.5
! 40 GHz  -19.9  -80.5  -81.2  -15.1
