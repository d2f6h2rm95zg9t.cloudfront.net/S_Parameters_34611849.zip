!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Monday, May 26, 2025 14:11:47
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -67.87 dB at 250 MHz (marker M1); lowest = -118.7 dB at 11.98 GHz (marker M2)
!   lowest |S11| = -38.2 dB at 20.92 GHz (marker M3), VSWR 1.02, Z = 50.5 - j1.15 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -46.4 to -9.9 dB; largest |S21 - S12| = 7.2e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.38, -0.20; 28.27 GHz: 1.24, +0.48; 34.24 GHz: 0.67, +0.34; 40 GHz: 1.06, -0.20
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -14.8  -67.9  -66.5  -9.9
! 448.8 MHz  -15.5  -90.1  -90.6  -11.3
! 1.84 GHz  -24.0  -100.6  -117.1  -15.0
! 7.008 GHz  -21.1  -106.2  -111.0  -15.9
! 8.001 GHz  -23.8  -109.9  -111.2  -10.9
! 9.79 GHz  -20.0  -102.6  -105.4  -14.9
! 11.38 GHz  -31.8  -105.8  -113.5  -15.3
! 11.98 GHz  -25.4  -118.7  -104.3  -15.5
! 13.57 GHz  -14.8  -104.7  -99.8  -16.8
! 18.54 GHz  -14.2  -96.1  -97.2  -29.0
! 20.12 GHz  -23.3  -98.0  -103.4  -46.2
! 20.92 GHz  -38.2  -88.1  -101.0  -35.4
! 21.52 GHz  -27.4  -93.6  -87.8  -33.3
! 22.51 GHz  -33.0  -97.7  -93.0  -30.2
! 23.7 GHz  -21.2  -95.5  -93.9  -27.7
! 26.88 GHz  -14.0  -89.8  -91.8  -20.0
! 28.27 GHz  -12.6  -92.9  -93.4  -19.7
! 33.44 GHz  -11.3  -88.9  -86.6  -15.1
! 34.24 GHz  -11.1  -87.3  -86.6  -13.7
! 38.21 GHz  -12.5  -84.4  -84.9  -12.8
! 39.6 GHz  -24.4  -83.3  -83.6  -13.6
! 40 GHz  -20.0  -84.0  -84.2  -14.0
