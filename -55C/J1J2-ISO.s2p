!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 22:29:37
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -70.33 dB at 35.03 GHz (marker M1); lowest = -123.0 dB at 2.436 GHz (marker M2)
!   lowest |S11| = -35.8 dB at 20.32 GHz (marker M3), VSWR 1.03, Z = 49.7 + j1.59 ohm
!   |S11| at or under -10 dB: start of sweep to 16.99 GHz; 17.79 GHz to 28.38 GHz (10.58 GHz wide, 45.8 % of centre); 29.48 GHz to 37.01 GHz (7.529 GHz wide, 22.7 % of centre) (the widest 3 of 4)
!   |S22| runs from -50.1 to -10.0 dB; largest |S21 - S12| = 3.6e-05
!   the Smith chart shows 11.78 GHz to 32.25 GHz only
!   S11 on the Smith chart (normalised r, x): 11.78 GHz: 0.76, -0.11; 18.14 GHz: 1.62, -0.44; 24.7 GHz: 0.76, +0.23; 28.67 GHz: 1.02, +0.71; 32.25 GHz: 0.99, -0.07
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -14.5  -94.1  -94.1  -10.1
! 1.442 GHz  -35.2  -104.8  -109.4  -15.0
! 2.436 GHz  -22.5  -123.0  -103.7  -14.8
! 7.008 GHz  -17.9  -112.2  -113.6  -15.3
! 9.79 GHz  -30.8  -108.1  -107.4  -15.1
! 11.78 GHz  -16.5  -100.2  -100.8  -15.8
! 13.57 GHz  -11.2  -105.4  -110.9  -17.0
! 15.36 GHz  -17.2  -107.6  -97.0  -18.8
! 18.14 GHz  -10.8  -94.3  -97.5  -28.7
! 20.12 GHz  -29.9  -96.8  -93.1  -27.3
! 20.32 GHz  -35.8  -99.8  -102.8  -26.6
! 21.32 GHz  -18.5  -110.8  -103.2  -22.9
! 24.7 GHz  -14.4  -91.5  -91.1  -17.2
! 26.88 GHz  -19.8  -84.9  -84.7  -14.8
! 28.67 GHz  -9.6  -98.5  -96.5  -14.3
! 30.86 GHz  -14.3  -93.7  -100.1  -16.1
! 32.25 GHz  -28.9  -81.1  -81.7  -20.7
! 33.44 GHz  -12.8  -81.7  -81.6  -27.9
! 34.44 GHz  -11.7  -74.3  -74.0  -50.1
! 35.03 GHz  -12.9  -70.3  -70.9  -34.3
! 36.42 GHz  -13.4  -75.1  -74.5  -23.3
! 40 GHz  -10.7  -81.4  -80.4  -19.2
