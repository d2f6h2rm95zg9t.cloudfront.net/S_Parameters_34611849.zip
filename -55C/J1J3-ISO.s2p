!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 22:31:41
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -70.80 dB at 36.62 GHz (marker M1); lowest = -126.5 dB at 22.51 GHz (marker M2)
!   lowest |S11| = -31.3 dB at 20.52 GHz (marker M3), VSWR 1.06, Z = 49.7 - j2.69 ohm
!   |S11| at or under -10 dB: start of sweep to 28.42 GHz; 30.08 GHz to 37.14 GHz (7.058 GHz wide, 21 % of centre); 39.21 GHz to 39.85 GHz (632.7 MHz wide, 1.6 % of centre)
!   |S22| runs from -23.1 to -9.8 dB; largest |S21 - S12| = 8.1e-05
!   the Smith chart shows 11.38 GHz to 33.64 GHz only
!   S11 on the Smith chart (normalised r, x): 11.38 GHz: 0.83, -0.14; 15.16 GHz: 1.14, -0.36; 17.94 GHz: 1.80, +0.04; 25.89 GHz: 1.09, +0.16; 33.64 GHz: 0.64, +0.02
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -20.4  -81.9  -80.6  -9.8
! 2.436 GHz  -25.6  -108.1  -117.3  -14.5
! 7.008 GHz  -16.7  -103.3  -108.9  -15.3
! 9.591 GHz  -28.0  -93.5  -93.9  -14.2
! 11.38 GHz  -18.3  -106.3  -109.1  -14.3
! 13.57 GHz  -10.7  -114.6  -111.7  -14.7
! 15.16 GHz  -15.0  -97.6  -98.5  -15.5
! 17.94 GHz  -10.9  -92.8  -92.5  -19.2
! 20.12 GHz  -23.9  -93.8  -92.1  -22.2
! 20.52 GHz  -31.3  -88.8  -94.6  -22.5
! 21.32 GHz  -19.9  -92.7  -101.2  -23.1
! 22.51 GHz  -18.7  -126.5  -90.9  -21.3
! 25.89 GHz  -21.0  -98.4  -91.9  -16.8
! 26.88 GHz  -24.9  -86.3  -93.1  -16.0
! 28.67 GHz  -9.5  -105.2  -95.3  -16.5
! 31.25 GHz  -13.1  -87.4  -81.6  -16.1
! 32.05 GHz  -18.7  -71.2  -71.0  -15.1
! 32.45 GHz  -24.3  -75.6  -75.0  -14.3
! 33.44 GHz  -14.5  -78.9  -78.5  -13.2
! 33.64 GHz  -13.2  -76.1  -75.4  -12.9
! 36.62 GHz  -12.2  -70.8  -71.7  -11.3
! 40 GHz  -9.6  -84.1  -86.2  -14.1
