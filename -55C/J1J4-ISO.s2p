!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Thursday, May 22, 2025 22:34:12
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -68.96 dB at 35.83 GHz (marker M1); lowest = -123.3 dB at 846.2 MHz (marker M2)
!   lowest |S11| = -36.6 dB at 9.79 GHz (marker M3), VSWR 1.03, Z = 51.1 - j1.03 ohm
!   |S11| at or under -10 dB: start of sweep to 17.1 GHz; 17.66 GHz to 28.26 GHz (10.6 GHz wide, 46.2 % of centre); 29.46 GHz to 37.33 GHz (7.868 GHz wide, 23.6 % of centre) (the widest 3 of 4)
!   |S22| runs from -36.7 to -9.8 dB; largest |S21 - S12| = 4.4e-05
!   the Smith chart shows 250 MHz to 24.1 GHz only
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.17, -0.12; 13.77 GHz: 1.07, +0.57; 16.35 GHz: 0.69, +0.29; 18.54 GHz: 1.22, -0.51; 24.1 GHz: 0.71, +0.07
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -20.3  -80.4  -80.4  -9.8
! 846.2 MHz  -20.3  -123.3  -113.1  -12.8
! 1.84 GHz  -26.7  -115.1  -100.4  -15.3
! 7.008 GHz  -16.9  -106.2  -103.3  -15.3
! 8.598 GHz  -21.2  -114.4  -101.6  -11.8
! 9.79 GHz  -36.6  -103.1  -106.2  -14.1
! 11.78 GHz  -15.9  -106.8  -99.4  -14.5
! 13.57 GHz  -11.3  -103.0  -108.9  -15.5
! 13.77 GHz  -11.5  -110.8  -106.3  -15.6
! 16.35 GHz  -12.2  -93.5  -93.7  -19.1
! 18.54 GHz  -12.2  -95.4  -99.2  -24.2
! 20.12 GHz  -28.7  -97.1  -88.9  -30.2
! 21.32 GHz  -17.8  -94.1  -88.6  -36.7
! 24.1 GHz  -15.1  -102.6  -99.7  -26.1
! 26.88 GHz  -20.5  -82.7  -84.2  -19.2
! 29.66 GHz  -10.3  -87.3  -85.9  -18.4
! 32.25 GHz  -29.9  -74.9  -73.1  -15.7
! 33.44 GHz  -12.8  -80.0  -81.2  -14.5
! 35.83 GHz  -15.5  -69.0  -69.0  -12.3
! 37.81 GHz  -9.4  -77.7  -76.7  -12.6
! 39.2 GHz  -18.4  -82.8  -82.4  -12.9
! 40 GHz  -10.3  -81.8  -80.0  -13.3
