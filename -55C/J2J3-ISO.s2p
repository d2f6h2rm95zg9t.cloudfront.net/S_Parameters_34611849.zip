!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Monday, May 26, 2025 13:54:25
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -78.73 dB at 34.44 GHz (marker M1); lowest = -143.3 dB at 6.411 GHz (marker M2)
!   lowest |S11| = -31.0 dB at 2.039 GHz (marker M3), VSWR 1.06, Z = 47.4 - j0.893 ohm
!   |S11| at or under -10 dB: start of sweep to 13.64 GHz; 15.04 GHz to 16.92 GHz (1.879 GHz wide, 11.8 % of centre); 17.45 GHz to end of sweep
!   |S22| runs from -23.1 to -9.8 dB; largest |S21 - S12| = 4.1e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.17, -0.10; 12.37 GHz: 0.93, -0.39; 17.74 GHz: 1.73, -0.41; 40 GHz: 0.98, +0.21
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -20.8  -93.0  -89.1  -9.8
! 1.045 GHz  -20.7  -109.0  -105.8  -13.1
! 2.039 GHz  -31.0  -101.4  -108.1  -15.2
! 3.43 GHz  -24.7  -104.3  -110.4  -10.3
! 4.821 GHz  -18.5  -108.9  -107.7  -14.7
! 6.411 GHz  -19.8  -143.3  -112.5  -15.8
! 7.008 GHz  -22.1  -113.3  -106.8  -15.4
! 8.2 GHz  -29.6  -115.5  -107.6  -10.1
! 9.591 GHz  -23.8  -108.2  -103.7  -14.3
! 10.78 GHz  -28.8  -102.2  -102.0  -14.4
! 12.37 GHz  -13.9  -107.0  -103.1  -14.5
! 13.57 GHz  -10.1  -108.5  -102.6  -14.7
! 17.74 GHz  -10.4  -95.2  -95.5  -19.0
! 20.12 GHz  -15.6  -101.9  -93.2  -21.7
! 26.88 GHz  -13.3  -94.4  -93.0  -16.0
! 28.47 GHz  -13.1  -93.7  -94.0  -16.4
! 29.86 GHz  -27.3  -100.9  -99.7  -16.7
! 31.06 GHz  -17.3  -90.5  -91.3  -16.2
! 33.44 GHz  -18.4  -80.5  -80.7  -13.1
! 34.44 GHz  -24.6  -78.7  -81.3  -12.1
! 38.01 GHz  -10.8  -90.6  -90.1  -12.0
! 40 GHz  -19.7  -84.5  -84.4  -14.3
