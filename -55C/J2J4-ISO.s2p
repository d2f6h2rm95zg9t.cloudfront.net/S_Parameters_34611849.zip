!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Monday, May 26, 2025 13:55:52
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -75.51 dB at 31.65 GHz (marker M1); lowest = -124.7 dB at 11.18 GHz (marker M2)
!   lowest |S11| = -30.9 dB at 2.039 GHz (marker M3), VSWR 1.06, Z = 47.4 - j0.909 ohm
!   |S11| at or under -10 dB: start of sweep to 13.64 GHz; 15.04 GHz to 16.92 GHz (1.886 GHz wide, 11.8 % of centre); 17.44 GHz to end of sweep
!   |S22| runs from -33.5 to -9.1 dB; largest |S21 - S12| = 3.7e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.17, -0.10; 12.37 GHz: 0.93, -0.39; 17.74 GHz: 1.72, -0.41; 40 GHz: 0.98, +0.21
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -20.7  -83.5  -85.6  -9.1
! 1.045 GHz  -20.7  -103.6  -113.5  -12.9
! 2.039 GHz  -30.9  -98.3  -109.1  -15.9
! 5.02 GHz  -18.1  -106.4  -112.3  -15.8
! 7.008 GHz  -22.1  -109.5  -100.2  -14.1
! 8.2 GHz  -29.6  -113.2  -106.3  -9.1
! 11.18 GHz  -23.9  -124.7  -101.2  -16.6
! 12.37 GHz  -13.9  -107.6  -117.3  -17.3
! 13.57 GHz  -10.1  -112.1  -104.4  -17.9
! 17.74 GHz  -10.4  -96.9  -100.9  -19.8
! 20.12 GHz  -15.6  -97.1  -95.7  -23.8
! 22.11 GHz  -16.7  -96.9  -101.6  -33.5
! 23.3 GHz  -13.3  -96.4  -96.8  -26.1
! 26.88 GHz  -13.3  -84.9  -87.0  -24.0
! 28.47 GHz  -13.1  -93.5  -85.9  -20.7
! 29.86 GHz  -27.2  -85.3  -90.9  -17.6
! 31.65 GHz  -15.8  -75.5  -76.7  -15.0
! 33.44 GHz  -18.4  -81.7  -82.4  -13.9
! 34.63 GHz  -25.4  -90.0  -92.2  -13.6
! 35.83 GHz  -15.4  -85.3  -86.8  -12.9
! 38.61 GHz  -10.6  -86.7  -87.4  -14.0
! 40 GHz  -19.7  -76.1  -76.1  -15.0
