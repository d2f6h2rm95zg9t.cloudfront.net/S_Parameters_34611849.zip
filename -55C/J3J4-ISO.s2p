!Agilent Technologies,E8364B,MY43040528,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Monday, May 26, 2025 13:57:34
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 250 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -73.98 dB at 35.83 GHz (marker M1); lowest = -128.2 dB at 10.19 GHz (marker M2)
!   lowest |S11| = -40.6 dB at 8.399 GHz (marker M3), VSWR 1.02, Z = 49.7 - j0.873 ohm
!   |S11| at or under -10 dB: start of sweep to 17.2 GHz; 17.6 GHz to end of sweep
!   |S22| runs from -35.7 to -9.8 dB; largest |S21 - S12| = 3.9e-05
!   S11 on the Smith chart (normalised r, x): 250 MHz: 1.22, -0.12; 17.74 GHz: 1.74, -0.44; 27.68 GHz: 1.00, +0.52; 34.24 GHz: 0.65, +0.35; 40 GHz: 1.16, -0.20
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 250 MHz  -18.9  -77.1  -76.0  -9.8
! 1.84 GHz  -30.9  -104.7  -105.8  -15.3
! 4.821 GHz  -17.7  -118.8  -107.1  -14.9
! 7.008 GHz  -20.9  -105.2  -108.9  -15.4
! 8.399 GHz  -40.6  -116.0  -106.3  -10.7
! 9.194 GHz  -24.1  -103.0  -101.7  -13.6
! 10.19 GHz  -21.4  -128.2  -99.1  -14.4
! 11.38 GHz  -30.8  -109.2  -100.6  -14.5
! 13.57 GHz  -11.9  -107.5  -102.8  -15.4
! 17.74 GHz  -10.1  -94.1  -93.1  -22.5
! 20.12 GHz  -18.3  -90.5  -99.8  -29.7
! 22.11 GHz  -25.0  -91.9  -100.6  -32.5
! 22.91 GHz  -40.5  -96.5  -100.1  -28.4
! 23.7 GHz  -19.7  -122.7  -92.9  -27.0
! 26.88 GHz  -12.8  -84.0  -83.3  -19.3
! 27.68 GHz  -12.0  -92.8  -88.9  -18.4
! 33.44 GHz  -10.8  -85.6  -87.8  -14.5
! 34.24 GHz  -10.7  -88.6  -85.5  -13.3
! 35.83 GHz  -10.4  -74.0  -74.1  -12.0
! 38.61 GHz  -11.9  -84.2  -85.8  -12.5
! 39.6 GHz  -27.6  -79.3  -78.7  -13.0
! 40 GHz  -18.5  -78.5  -79.5  -13.5
